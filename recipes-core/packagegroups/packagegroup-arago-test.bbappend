ARAGO_TEST += " \
	protocoltester \
	pll \
"
